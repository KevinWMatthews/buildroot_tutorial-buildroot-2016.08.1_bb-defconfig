## package/hello-world/Config.in
```kconfig
config BR2_PACKAGE_HELLO_WORLD
    bool "hello-world"
    help
      Greet the world of buildroot.
```
